options:
  parameters:
    author: henningM1r
    generate_options: qt_gui
    id: MSF60_Receiver
    output_language: python
    title: MSF60 Receiver
  states: {}

blocks:
- name: cutoff
  id: variable_qtgui_range
  parameters:
    label: LP cut-off
    start: '5'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '15'
  states: {}
- name: freq_MSF60
  id: variable
  parameters:
    value: '60000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Amplify receving
      signal power
    gui_hint: (2,0)
    label: Recv Gain
    start: '1'
    step: '1'
    stop: '10000'
    value: '5000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adapt the upper threshold
      so that the one value is
      provided each time the
      signal is high
    gui_hint: (1,0)
    label: Threshold
    start: '0'
    step: '10'
    stop: '5000'
    value: '2500'
  states: {}
- name: variable_low_pass_filter_taps_1
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '600'
    gain: '500'
    samp_rate: samp_rate
    width: '150'
    win: window.WIN_RECTANGULAR
  states: {}
- name: width
  id: variable_qtgui_range
  parameters:
    label: LP width
    start: '25'
    step: '1'
    stop: '150'
    value: '35'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: thres
    comment: only to display threshold
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_add_const_vxx_2
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      is only scaled to be
      visible in output
    const: '3500'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Decide if received
      value is zero or one
    high: thres
    init: '1'
    low: thres
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\n# counted number of one samples\n_num_ones = 0\n\n# counted number of zero samples\n_num_zeros = 0\n\nclass MSF60_BitDetector_blk(gr.sync_block):\n\n    def __init__(self, sample_rate=12800, tolerance=0.02):\n        gr.sync_block.__init__(\n            self,\n            name='MSF60\\nBit Detector',\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n\n        # block paramters\n        # NOTE: use decimated sample rate: samp_rate/decimation\n        self.sample_rate = sample_rate\n\n        # messaging port\n        self.message_port_register_out(pmt.intern('msg_out'))\n\n        # timing tolerance value, if the sampled frame is\n        # slightly shorter/longer hant the defined duration\n        self._tolerance = self.sample_rate*tolerance\n\n        self._sec = self.sample_rate * 0.1\n        self._sec_lo = self._sec - self._tolerance\n\n        self.queue_len = 2\n        self.queue = gr.msg_queue(self.queue_len)\n\n    def work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n\n        out[:] = self.extract_bits(inp)\n\n        # forward input tagged signal\n        return len(out)\n\n    def send_msg(self, val, num):\n        # handles both the message ouput queue\n        # and the message transmission\n        _msg = \"\"\n\n        if num > 0:\n            for i in range(0, num):\n                _msg += val\n\n            # convert python string to message\n            msg1_in = gr.message_from_string(_msg)\n\n            # insert message into queue\n            self.queue.insert_tail(msg1_in)\n\n        msg_list = [0]*self.queue_len\n\n        # send a combination of all messages contained in queue\n        if self.queue.full_p():\n            for idx in range(0, self.queue_len):\n                msg_list[idx] = self.queue.delete_head().\\\n                                     to_string().decode(\"utf-8\")\n\n            msg1_out = \"\".join(map(str, msg_list))\n            self.message_port_pub(pmt.intern(\"msg_out\"),\n                                  pmt.intern(msg1_out))\n\n    def clear_counters(self):\n        global _num_ones\n        global _num_zeros\n\n        # reset counters\n        _num_ones = 0\n        _num_zeros = 0\n\n    def extract_bits(self, inp):\n        global _num_ones\n        global _num_zeros\n\n        out = np.zeros(len(inp))\n\n        for idx, ch in enumerate(inp):\n            # increment current counters of zeros and ones correspondingly\n            if (ch == 1):\n                _num_ones += 1\n            else:   # ch == 0\n                _num_zeros += 1\n\n            # triggers upon first one after multiple zeros\n            if (ch == 1 and\n                _num_zeros >= self._sec_lo):\n\n                _num = round(_num_zeros/self._sec)\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(f\"0,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                self.send_msg(val=\"0,\", num=_num)\n\n                self.clear_counters()\n\n            # triggers upon first zero after multiple ones\n            elif (ch == 0 and\n                _num_ones >= self._sec_lo):\n\n                _num = round(_num_ones/self._sec)\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(f\"1,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                self.send_msg(val=\"1,\", num=_num)\n\n                self.clear_counters()  \n\n        # return (float) signal block\n        return out\n"
    alias: MSF60_Bit_Detector
    comment: |-
      Detects MSF60
      OOK Symbols:
      * second marker
      * minute marker
      * A bit (0 or 1)
      * B bit (0 or 1)
    sample_rate: int(samp_rate/decimation)
    tolerance: '0.03'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nfrom scipy.spatial.distance import hamming\n\n\n# sliding window for selected messages\n_msg_window = np.empty(shape=(1, 1))\n\nclass MSF60_correlator_blk(gr.sync_block):\n\n    def __init__(self):\n        gr.basic_block.__init__(\n            self,\n            name=\"MSF60\\nCorrelator\",\n            in_sig=None,\n            out_sig=None)\n \n        # prepare in and out ports for messages\n        self.message_port_register_out(pmt.intern('msg_out'))\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n        # MSF60:\n        # 1st bit: second marker\n        # 2nd bit: A bit\n        # 3rd bit: B bit\n        self.code_dict = {\n                            \"00\": (0,1,1,1,1,1,1,1,1,1),\n                            \"10\": (0,0,1,1,1,1,1,1,1,1),\n                            \"11\": (0,0,0,1,1,1,1,1,1,1),\n                            \"01\": (0,1,0,1,1,1,1,1,1,1),\n                            \"2\":  (0,0,0,0,0,1,1,1,1,1),\n                         }\n\n        self.symbol_code_swap_dict = \\\n            {v: k for k, v in self.code_dict.items()}\n\n        self.cw_len = 10\n\n    def prepare_window(self, msg):\n        global _msg_window\n\n        # message contains the whole sequence of a received second\n        msg = pmt.to_python(msg)\n\n        # first put each string into an array (separated by comma)\n        received_msg = msg.split(\",\")\n\n        # truncate last element (\"\") from list\n        received_msg = received_msg[:-1]\n\n        # convert to numpy-array\n        np_recv_seq = np.array(received_msg)\n\n        # turn each array element into an integer value\n        np_recv_seq = np.asarray(np_recv_seq, dtype=np.int32)\n\n        _msg_window = np.append(_msg_window, np_recv_seq)\n\n    def compare_code(self, window, cw_len):\n        min_dist = cw_len\n        idx = 0\n        res_cw = None\n\n        # decision metric: compare window with codewords\n        # using the Hamming-metric\n        for offset in range(0, max(1, len(window) - cw_len + 1)):\n\n            for codeword in self.symbol_code_swap_dict:\n                # turn tuple into numpy array\n                np_cw = np.array(list(codeword))\n                dist = hamming(window[offset:offset + cw_len], np_cw)\n\n                # update (reduce) current minimum\n                if min_dist > dist:\n                    min_dist = dist\n\n                # check decision threshold for minimum\n                if min_dist == 0.0:\n                    idx = offset\n                    res_cw = self.symbol_code_swap_dict[codeword]\n                    return [res_cw, idx]\n\n        # no codeword detected\n        if min_dist > 0.0:\n            idx = 0\n            res_cw = None\n\n        return [res_cw, idx]\n\n    def handle_msg(self, msg):\n        global _msg_window\n\n        self.prepare_window(msg)\n        codeword = None\n\n        if len(_msg_window) >= 10:\n            cur_window = _msg_window.copy()\n\n            [codeword, idx] = \\\n                self.compare_code(\n                window= cur_window,\n                cw_len=self.cw_len)\n\n            if codeword != None:\n                msg1_out = codeword\n                self.message_port_pub(pmt.intern(\"msg_out\"),\n                                      pmt.intern(msg1_out))\n                # truncate sliding window \n                _msg_window = _msg_window[idx + self.cw_len:]\n\n            else:\n                # no codeword detected\n                # truncate sliding window \n                _msg_window = _msg_window[9:]        \n\n"
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: |-
      Demodulation from 60 kHz
      down to the base band.
    decim: decimation
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_1
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '60000'
    comment: |-
      Demodulation from 60 kHz
      down to the base band.
    decim: decimation
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_1
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    comment: |-
      Windows needs the
      import of zmq
    imports: import zmq
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: dense low-pass filter
    cutoff_freq: cutoff
    decim: '1'
    gain: gain
    samp_rate: int(samp_rate/decimation)
    type: fir_filter_ccf
    width: width
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    comment: dense low-pass filter
    cutoff_freq: cutoff
    decim: '1'
    gain: 1/5
    samp_rate: int(samp_rate/decimation)
    type: fir_filter_ccf
    width: width
    win: window.WIN_BLACKMAN
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '55554'
    server: 'False'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      * https://drtonyr.github.io/MSF60decoder/
      * https://www.npl.co.uk/products-services/time-frequency/msf-radio-time-signal/msf_time_date_code
      * https://en.wikipedia.org/wiki/Time_from_NPL_(MSF)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '35'
    bw0: '4000'
    comment: |-
      frame is localized on the
      center frequency of the
      MSF60 signal
    freq0: freq_MSF60
    gain0: '35'
    gain_mode0: 'True'
    if_gain0: '35'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (5,0)
    name: '"received complex signal spectrum"'
    type: complex
    update_time: '0.025'
    ymax: '30'
    ymin: '-110'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      view the noisy input signal
      to set the thresholds properly
    gui_hint: (6,0)
    label1: BB Signal
    label2: Signal after Thresh.
    label3: Symbols
    label4: Thresh. Value
    name: Signals
    nconnections: '4'
    size: int(samp_rate*4/decimation)
    srate: samp_rate
    type: float
    update_time: '0.025'
    ymax: '18000'
    ymin: '-1000'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    comment: |-
      publish to be read by the
      python tool via ZMQ for instance
    timeout: '500'
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_add_const_vxx_2, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_threshold_ff_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0, '2']
- [epy_block_0, msg_out, blocks_message_debug_0, print]
- [epy_block_0, msg_out, epy_block_1, msg_in]
- [epy_block_1, msg_out, blocks_message_debug_0_0, print]
- [epy_block_1, msg_out, zeromq_push_msg_sink_0, in]
- [freq_xlating_fir_filter_xxx_0_0, '0', low_pass_filter_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_add_const_vxx_2, '0']
- [low_pass_filter_0_0_0, '0', blocks_add_const_vxx_2, '0']
- [network_tcp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', blocks_threshold_ff_0, '0']

metadata:
  file_format: 1
